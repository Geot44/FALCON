## falcon_imu_test/Kconfig
```kconfig
rsource "${SdkRootDirPath}/Kconfig.mcuxpresso"
orsource "${board}/Kconfig.trace"
```
